# Keil uVision project icm-20948.uvprojx, settings and files
target icm-20948 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: icm-20948
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\icm-20948\cmsis\inc;.\icm-20948\code\inc;..\workspace
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./icm-20948/startup/: startup_stm32f411xe.s
  group cmsis
    ./icm-20948/cmsis/src/: system_stm32f4xx.c
  group code
    ./icm-20948/code/src/: icm-20948.c main.c spi2.c timer_delays.c uart2.c
