# Keil uVision project mpu6500.uvprojx, settings and files
target mpu6500 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpu6500
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\mpu6500\code\inc;.\mpu6500\cmsis\inc;..\workspace
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./mpu6500/startup/: startup_stm32f411xe.s
  group cmsis
    ./mpu6500/cmsis/src/: system_stm32f4xx.c
  group code
    ./mpu6500/code/src/: main.c timer_delays.c spi2.c uart2.c mpu6500.c
