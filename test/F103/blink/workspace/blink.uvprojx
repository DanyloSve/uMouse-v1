# Keil uVision project blink.uvprojx, settings and files
target blink (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group code
    ./code/code/src/: main.c
  group cmsis
    ./code/cmsis/src/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group startup
    ./code/startup/: startup_stm32f10x_md_vl.s
