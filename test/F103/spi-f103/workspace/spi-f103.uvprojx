# Keil uVision project spi-f103.uvprojx, settings and files
target spi-f103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: spi-f103
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\spi-f103\cmsis\inc;.\spi-f103\code\inc;..\workspace
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group code
    ./spi-f103/code/src/: main.c timer_delays.c spi1.c spi2.c mpu6500.c
  group cmsis
    ./spi-f103/cmsis/src/: core_cm3.c system_stm32f10x.c
  group startup
    ./spi-f103/startup/: startup_stm32f10x_md_vl.s
