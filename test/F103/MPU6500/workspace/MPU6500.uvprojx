# Keil uVision project MPU6500.uvprojx, settings and files
target MPU6500 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6500
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\workspace;.\MPU6500\cmsis\inc;.\MPU6500\code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./MPU6500/startup/: startup_stm32f10x_md_vl.s
  group cmsis
    ./MPU6500/cmsis/src/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group code
    ./MPU6500/code/src/: main.c mpu6500.c spi1.c spi2.c timer_delays.c lcd.c i2c1.c
