# Keil uVision project bluetooth.uvprojx, settings and files
target bluetooth (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bluetooth
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\bluetooth\cmsis\inc;.\bluetooth\code\inc;..\workspace
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./bluetooth/startup/: startup_stm32f10x_md_vl.s
  group cmsis
    ./bluetooth/cmsis/src/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group code
    ./bluetooth/code/src/: main.c timer_delays.c uart1.c
